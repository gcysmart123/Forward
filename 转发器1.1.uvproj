# Keil uVision project 转发器1.1.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: 转发器1.1 +hex
  c flags: Optimize=9 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 delay.c display.c ev1527.c Function.c key.c main.c memu.c pca.c out.c timer.c timer_2_2.c EEPRAM.C
